Commit message: fixed the hw0 rprbot.urdf

File: urdf_models/rprbot.urdf (robot description, URDF)
Before this commit: robot rprbot, 4 links, 3 joints
Links:
- link link2: mass 2 -> 1; geometry visual cylinder length=1.5 radius=0.03; visual sphere radius=0.09
